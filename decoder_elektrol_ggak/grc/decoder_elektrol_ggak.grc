options:
  parameters:
    author: OpenAI / generated for Dario Lucia
    category: Satellite
    comment: 'Elektro-L 5 GGAK diagnostic receiver v1.4. PM demodulation now follows the current SatDump PMDemodModule architecture: resample to 10 sps, AGC, carrier PLL, PMToBPSK imag-only + -symbolrate shift, complex RRC, order-2 Costas, M&M clock recovery.'
    description: Elektro-L 5 GGAK 1693 MHz, 5 ksym/s PM/BPSK, SatDump-equivalent PM demod, CCSDS ASM 1ACFFC1D, 1792-bit CADU
    generate_options: qt_gui
    id: elektro_l5_ggak
    output_language: python
    run_options: run
    title: Elektro-L 5 GGAK Decoder
  states: {}

blocks:
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: frequency_hz
  id: variable
  parameters:
    comment: GGAK RF frequency
    value: '1693000000'
  states: {}
- name: frequency_correction_hz
  id: variable
  parameters:
    comment: Static correction for receiver/reference error
    value: '0'
  states: {}
- name: lo_offset_hz
  id: variable
  parameters:
    comment: Keep signal away from Pluto zero-IF/DC spike
    value: '-250000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Pluto hardware sample rate
    value: '2000000'
  states: {}
- name: decimation
  id: variable
  parameters:
    comment: Channel-filter decimation
    value: '8'
  states: {}
- name: post_rate
  id: variable
  parameters:
    value: samp_rate/decimation
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    comment: GGAK symbol rate
    value: '5000'
  states: {}
- name: timing_decimation
  id: variable
  parameters:
    comment: Resample/decimate before AGC/PLL to SatDump MAX_SPS=10
    value: '5'
  states: {}
- name: timing_rate
  id: variable
  parameters:
    comment: SatDump-equivalent PM demod sample rate (50 kS/s)
    value: post_rate/timing_decimation
  states: {}
- name: sps
  id: variable
  parameters:
    comment: Samples/symbol at Costas/MM input; 10 by default
    value: timing_rate/symbol_rate
  states: {}
- name: iio_fmcomms2_source_0
  id: iio_fmcomms2_source
  parameters:
    type: fc32
    uri: '"ip:192.168.2.1"'
    frequency: int(frequency_hz + frequency_correction_hz + lo_offset_hz)
    samplerate: int(samp_rate)
    buffer_size: '32768'
    rx1_en: 'True'
    rx2_en: 'False'
    quadrature: 'True'
    rfdc: 'True'
    bbdc: 'True'
    gain1: '''manual'''
    manual_gain1: '40.0'
    rf_port_select: '''A_BALANCED'''
    len_tag_key: '""'
    filter_source: '''Auto'''
    filter: '""'
    bandwidth: '1500000'
    comment: Pluto Plus source; default LO = 1692.750 MHz so GGAK is +250 kHz in baseband.
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-lo_offset_hz'
    comment: Channelize GGAK from +250 kHz to DC and decimate 2 MS/s -> 250 kS/s. Spectrum widget taps here.
    decim: decimation
    samp_delay: '0'
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, 40000, 15000, window.WIN_HAMMING)
    type: ccc
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.2'
    bw: post_rate
    comment: Spectrum immediately after channel filter/decimation.
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    gui_hint: 0,0,1,1
    label1: Filtered GGAK
    name: Post-filter spectrum (250 kS/s)
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    alpha1: '0.7'
    comment: Direct complex output of Costas + M&M recovery. Correct BPSK should form two compact clusters near +/-I, with small Q spread.
    grid: 'True'
    gui_hint: 0,1,1,1
    label1: Recovered BPSK symbols
    name: Post-Costas / M&M constellation
    size: '2048'
    type: complex
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    comment: 'SatDump-style pre-demod resampling stage: anti-alias LPF + x5 decimation, 250 kS/s -> 50 kS/s (10 samples/symbol).'
    decim: timing_decimation
    gain: '1'
    interp: '1'
    taps: firdes.low_pass(1.0, post_rate, 20000, 4000, window.WIN_HAMMING)
    type: ccc
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    comment: 'Equivalent to SatDump BaseDemodModule AGC defaults: rate=1e-2, reference=1, initial gain=1, max gain=65536.'
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-2'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_pll_carriertracking_cc_0
  id: analog_pll_carriertracking_cc
  parameters:
    comment: Carrier PLL. Uses Elektro GGAK SatDump pll_bw=0.02 and PMDemod default max offset +/-0.5 rad/sample.
    max_freq: '0.5'
    min_freq: '-0.5'
    w: '0.02'
  states: {}
- name: epy_block_pm
  id: epy_block
  parameters:
    sample_rate: timing_rate
    symbol_rate: symbol_rate
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          """SatDump PMToBPSK equivalent.

          For each PLL output sample, discard I and keep only j*Q, then rotate
          continuously by -symbol_rate. This mirrors SatDump's PMToBPSK block.
          Input/output are complex64.
          """
          def __init__(self, sample_rate=50000, symbol_rate=5000):
              gr.sync_block.__init__(self, name='PMToBPSK (SatDump equivalent)',
                                    in_sig=[np.complex64], out_sig=[np.complex64])
              self.sample_rate = float(sample_rate)
              self.symbol_rate = float(symbol_rate)
              self.phase = 0.0
              self.phase_inc = -2.0*np.pi*self.symbol_rate/self.sample_rate

          def work(self, input_items, output_items):
              x = input_items[0]
              n = len(x)
              if n == 0:
                  return 0
              idx = np.arange(n, dtype=np.float64)
              ph = self.phase + self.phase_inc*idx
              rot = np.exp(1j*ph)
              y = (1j*x.imag.astype(np.float64))*rot
              output_items[0][:n] = y.astype(np.complex64)
              self.phase = float((self.phase + self.phase_inc*n + np.pi) % (2.0*np.pi) - np.pi)
              return n
    comment: 'Exact functional equivalent of current SatDump PMToBPSK: x -> j*imag(x), then NCO shift by -symbol_rate.'
  states: {}
- name: fir_filter_xxx_1
  id: fir_filter_xxx
  parameters:
    comment: 'Complex RRC matched filter matching SatDump PMDemod defaults: alpha=0.5, exactly 31 taps.'
    decim: '1'
    gain: '1'
    interp: '1'
    taps: firdes.root_raised_cosine(1.0, timing_rate, symbol_rate, 0.5, 31)
    type: ccc
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    comment: Order-2 BPSK Costas loop matching SatDump PMDemod default costas_bw=0.005.
    order: '2'
    w: '0.005'
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    comment: M&M timing recovery matching SatDump PMDemod defaults. Outputs one complex sample per recovered symbol.
    gain_mu: '0.01'
    gain_omega: pow(0.01,2)/4.0
    mu: '0.5'
    omega: sps
    omega_relative_limit: '0.005'
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    frame_bits: '1792'
    search_errors: '2'
    locked_errors: '4'
    output_file: '"ggak_frames.bin"'
    _source_code: |
      import numpy as np
      import time
      from gnuradio import gr
      import pmt

      ASM = 0x1ACFFC1D
      ASM_BITS = np.array([(ASM >> (31-i)) & 1 for i in range(32)], dtype=np.uint8)

      class blk(gr.sync_block):
          """Elektro-L 5 GGAK CCSDS ASM deframer.

          Input: one recovered complex BPSK symbol per item (slice on real part).
          Output 'frames': 220-byte GGAK frame, with 32-bit ASM removed
          from the 224-byte / 1792-bit CADU. Both normal and inverted polarity
          are accepted. Only frames passing the empirical additive checksum are
          published and recorded; the checksum bytes are retained.
          """
          def __init__(self, frame_bits=1792, search_errors=2, locked_errors=4, output_file='ggak_frames.bin'):
              gr.sync_block.__init__(self, name='GGAK ASM deframer', in_sig=[np.complex64], out_sig=None)
              self.message_port_register_out(pmt.intern('frames'))
              self.frame_bits = int(frame_bits)
              self.search_errors = int(search_errors)
              self.locked_errors = int(locked_errors)
              self._window = []
              self._collect = None
              self._invert = False
              self._locked = False
              self._asm_errors = 0
              self.frames = 0
              self.rejected_frames = 0
              if self.frame_bits != 1792:
                  raise ValueError("GGAK checksum requires 1792-bit CADUs (220-byte frames)")
              self.output_file = str(output_file)
              self._fh = open(self.output_file, 'wb') if self.output_file else None
              if self._fh is not None:
                  print('[GGAK] recording frames to %s' % self.output_file)

          def _publish(self, bits):
              packed = np.packbits(np.asarray(bits, dtype=np.uint8), bitorder='big').tobytes()
              tm = packed[4:]
              # Check canonical frame octets after polarity normalization and ASM removal.
              expected = (sum(tm[:218]) + 0x0202) & 0xffff
              received = (tm[218] << 8) | tm[219]
              if expected != received:
                  self.rejected_frames += 1
                  print('[GGAK] checksum reject: expected=%04X received=%04X, valid=%d rejected=%d' %
                        (expected, received, self.frames, self.rejected_frames))
                  return
              meta = pmt.make_dict()
              meta = pmt.dict_add(meta, pmt.intern('checksum_valid'), pmt.PMT_T)
              meta = pmt.dict_add(meta, pmt.intern('checksum'), pmt.from_long(received))
              meta = pmt.dict_add(meta, pmt.intern('rx_time_ns'), pmt.from_long(time.time_ns()))
              meta = pmt.dict_add(meta, pmt.intern('frame_type'), pmt.intern('GGAK'))
              meta = pmt.dict_add(meta, pmt.intern('asm_errors'), pmt.from_long(self._asm_errors))
              meta = pmt.dict_add(meta, pmt.intern('cadu_length'), pmt.from_long(len(packed)))
              self.message_port_pub(pmt.intern('frames'), pmt.cons(meta, pmt.init_u8vector(len(tm), list(tm))))
              if self._fh is not None:
                  self._fh.write(tm)
                  self._fh.flush()
              self.frames += 1
              print('[GGAK] frame %d: %d bytes GGAK frame, checksum=OK, ASM errors=%d, header=%s, rejected=%d' %
                    (self.frames, len(tm), self._asm_errors, tm[:8].hex(), self.rejected_frames))

          def work(self, input_items, output_items):
              for sample in input_items[0]:
                  bit = 1 if sample.real >= 0 else 0
                  if self._collect is not None:
                      self._collect.append(bit ^ int(self._invert))
                      if len(self._collect) >= self.frame_bits:
                          bits = self._collect
                          self._collect = None
                          self._publish(bits)
                          self._locked = True
                      continue
                  self._window.append(bit)
                  if len(self._window) > 32:
                      self._window.pop(0)
                  if len(self._window) == 32:
                      w = np.asarray(self._window, dtype=np.uint8)
                      e = int(np.count_nonzero(w != ASM_BITS))
                      ei = int(np.count_nonzero((1-w) != ASM_BITS))
                      threshold = self.locked_errors if self._locked else self.search_errors
                      if min(e, ei) <= threshold:
                          self._invert = ei < e
                          self._asm_errors = min(e, ei)
                          self._collect = ASM_BITS.tolist()
                          self._window = []
              return len(input_items[0])

          def stop(self):
              if self._fh is not None:
                  self._fh.flush()
                  self._fh.close()
                  self._fh = None
              return True
    comment: 'Emits and records only 220-byte GGAK frames passing additive checksum: (sum(frame[:218])+0x0202)&0xffff, big-endian bytes 218–219.'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    comment: Optional PDU display. The embedded deframer also prints a compact one-line summary per frame.
    en_uvec: 'False'
  states: {}

connections:
- [iio_fmcomms2_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', fir_filter_xxx_0, '0']
- [fir_filter_xxx_0, '0', analog_agc_xx_0, '0']
- [analog_agc_xx_0, '0', analog_pll_carriertracking_cc_0, '0']
- [analog_pll_carriertracking_cc_0, '0', epy_block_pm, '0']
- [epy_block_pm, '0', fir_filter_xxx_1, '0']
- [fir_filter_xxx_1, '0', digital_costas_loop_cc_0, '0']
- [digital_costas_loop_cc_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', qtgui_const_sink_x_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', epy_block_0, '0']
- [epy_block_0, frames, blocks_message_debug_0, print]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
