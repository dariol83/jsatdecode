options:
  parameters:
    author: OpenAI / generated for Dario Lucia
    category: Satellite
    comment: 'Elektro-L 5 GGAK diagnostic receiver v1.5. v1.5 changes vs v1.4: (1) blind carrier acquisition/AFC from the 2*fc line of x^2 (data independent) instead of relying on the carrier PLL to find the residual carrier; (2) carrier PLL narrowed 0.02 -> 0.002 rad/sample, +/-200 Hz; (3) analog AGC replaced by a level-independent power normaliser placed before Costas/M&M; (4) M&M gain_mu 0.01 -> 0.02. File source (cs16) added; Pluto source kept but disabled.'
    description: Elektro-L 5 GGAK 1693 MHz, 5 ksym/s PM/BPSK, blind-AFC PM demod, CCSDS ASM 1ACFFC1D, 1792-bit CADU
    generate_options: qt_gui
    id: elektro_l5_ggak
    output_language: python
    run_options: run
    title: Elektro-L 5 GGAK Decoder v1.5
  states: {}

blocks:
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: frequency_hz
  id: variable
  parameters:
    comment: GGAK RF frequency
    value: '1693000000'
  states: {}
- name: frequency_correction_hz
  id: variable
  parameters:
    comment: Static correction for receiver/reference error
    value: '0'
  states: {}
- name: lo_offset_hz
  id: variable
  parameters:
    comment: Keep signal away from Pluto zero-IF/DC spike
    value: '-250000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: 'Input sample rate: 1 MS/s for the SatDump cs16 recording, 2 MS/s Pluto. Any integer multiple of 250 kS/s works.'
    value: 1000000 if use_file else 2000000
  states: {}
- name: decimation
  id: variable
  parameters:
    comment: Channel-filter decimation to 250 kS/s
    value: int(round(samp_rate/250000.0))
  states: {}
- name: post_rate
  id: variable
  parameters:
    value: samp_rate/decimation
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    comment: GGAK symbol rate
    value: '5000'
  states: {}
- name: timing_decimation
  id: variable
  parameters:
    comment: Resample/decimate before AGC/PLL to SatDump MAX_SPS=10
    value: '5'
  states: {}
- name: timing_rate
  id: variable
  parameters:
    comment: SatDump-equivalent PM demod sample rate (50 kS/s)
    value: post_rate/timing_decimation
  states: {}
- name: sps
  id: variable
  parameters:
    comment: Samples/symbol at Costas/MM input; 10 by default
    value: timing_rate/symbol_rate
  states: {}
- name: iio_fmcomms2_source_0
  id: iio_fmcomms2_source
  parameters:
    type: fc32
    uri: '"ip:192.168.2.1"'
    frequency: int(frequency_hz + frequency_correction_hz + lo_offset_hz)
    samplerate: int(samp_rate)
    buffer_size: '32768'
    rx1_en: 'True'
    rx2_en: 'False'
    quadrature: 'True'
    rfdc: 'True'
    bbdc: 'True'
    gain1: '''manual'''
    manual_gain1: '40.0'
    rf_port_select: '''A_BALANCED'''
    len_tag_key: '""'
    filter_source: '''Auto'''
    filter: '""'
    bandwidth: '1500000'
    comment: Pluto Plus source; default LO = 1692.750 MHz so GGAK is +250 kHz in baseband.
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: channel_offset_hz
    comment: Channelize GGAK to DC and decimate to 250 kS/s. 60 kHz cutoff so the blind AFC can find carrier offsets up to +/-30 kHz. Spectrum widget taps here.
    decim: decimation
    samp_delay: '0'
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, 60000, 20000, window.WIN_HAMMING)
    type: ccc
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.2'
    bw: post_rate
    comment: Spectrum immediately after channel filter/decimation.
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    gui_hint: 0,0,1,1
    label1: Filtered GGAK
    name: Post-filter spectrum (250 kS/s)
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    alpha1: '0.7'
    comment: Direct complex output of Costas + M&M recovery. Correct BPSK should form two compact clusters near +/-I, with small Q spread.
    grid: 'True'
    gui_hint: 0,1,1,1
    label1: Recovered BPSK symbols
    name: Post-Costas / M&M constellation
    size: '2048'
    type: complex
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    comment: 'SatDump-style pre-demod resampling stage: anti-alias LPF + x5 decimation, 250 kS/s -> 50 kS/s (10 samples/symbol).'
    decim: timing_decimation
    gain: '1'
    interp: '1'
    taps: firdes.low_pass(1.0, post_rate, 20000, 4000, window.WIN_HAMMING)
    type: ccc
  states: {}
- name: analog_pll_carriertracking_cc_0
  id: analog_pll_carriertracking_cc
  parameters:
    comment: Narrow carrier PLL (0.002 rad/sample, +/-200 Hz = +/-0.025 rad/sample). Coarse acquisition is done by the AFC block; a wide loop only adds phase noise on the weak residual carrier.
    max_freq: '0.025'
    min_freq: '-0.025'
    w: '0.002'
  states: {}
- name: epy_block_pm
  id: epy_block
  parameters:
    sample_rate: timing_rate
    symbol_rate: symbol_rate
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          """SatDump PMToBPSK equivalent.

          For each PLL output sample, discard I and keep only j*Q, then rotate
          continuously by -symbol_rate. This mirrors SatDump's PMToBPSK block.
          Input/output are complex64.
          """
          def __init__(self, sample_rate=50000, symbol_rate=5000):
              gr.sync_block.__init__(self, name='PMToBPSK (SatDump equivalent)',
                                    in_sig=[np.complex64], out_sig=[np.complex64])
              self.sample_rate = float(sample_rate)
              self.symbol_rate = float(symbol_rate)
              self.phase = 0.0
              self.phase_inc = -2.0*np.pi*self.symbol_rate/self.sample_rate

          def work(self, input_items, output_items):
              x = input_items[0]
              n = len(x)
              if n == 0:
                  return 0
              idx = np.arange(n, dtype=np.float64)
              ph = self.phase + self.phase_inc*idx
              rot = np.exp(1j*ph)
              y = (1j*x.imag.astype(np.float64))*rot
              output_items[0][:n] = y.astype(np.complex64)
              self.phase = float((self.phase + self.phase_inc*n + np.pi) % (2.0*np.pi) - np.pi)
              return n
    comment: 'Exact functional equivalent of current SatDump PMToBPSK: x -> j*imag(x), then NCO shift by -symbol_rate.'
  states: {}
- name: fir_filter_xxx_1
  id: fir_filter_xxx
  parameters:
    comment: 'Complex RRC matched filter matching SatDump PMDemod defaults: alpha=0.5, exactly 31 taps.'
    decim: '1'
    gain: '1'
    interp: '1'
    taps: firdes.root_raised_cosine(1.0, timing_rate, symbol_rate, 0.5, 31)
    type: ccc
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    comment: Order-2 BPSK Costas loop matching SatDump PMDemod default costas_bw=0.005.
    order: '2'
    w: '0.005'
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    comment: M&M timing recovery. gain_mu 0.02 (was 0.01); input amplitude now normalised so the loop gains are as designed.
    gain_mu: '0.02'
    gain_omega: pow(0.01,2)/4.0
    mu: '0.5'
    omega: sps
    omega_relative_limit: '0.005'
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    frame_bits: '1792'
    search_errors: '2'
    locked_errors: '4'
    output_file: '"ggak_frames.bin"'
    _source_code: |
      import numpy as np
      import time
      from gnuradio import gr
      import pmt

      ASM = 0x1ACFFC1D
      ASM_BITS = np.array([(ASM >> (31-i)) & 1 for i in range(32)], dtype=np.uint8)

      class blk(gr.sync_block):
          """Elektro-L 5 GGAK CCSDS ASM deframer.

          Input: one recovered complex BPSK symbol per item (slice on real part).
          Output 'frames': 220-byte GGAK frame, with 32-bit ASM removed
          from the 224-byte / 1792-bit CADU. Both normal and inverted polarity
          are accepted. Only frames passing the empirical additive checksum are
          published and recorded; the checksum bytes are retained.
          """
          def __init__(self, frame_bits=1792, search_errors=2, locked_errors=4, output_file='ggak_frames.bin'):
              gr.sync_block.__init__(self, name='GGAK ASM deframer', in_sig=[np.complex64], out_sig=None)
              self.message_port_register_out(pmt.intern('frames'))
              self.frame_bits = int(frame_bits)
              self.search_errors = int(search_errors)
              self.locked_errors = int(locked_errors)
              self._window = []
              self._collect = None
              self._invert = False
              self._locked = False
              self._asm_errors = 0
              self.frames = 0
              self.rejected_frames = 0
              if self.frame_bits != 1792:
                  raise ValueError("GGAK checksum requires 1792-bit CADUs (220-byte frames)")
              self.output_file = str(output_file)
              self._fh = open(self.output_file, 'wb') if self.output_file else None
              if self._fh is not None:
                  print('[GGAK] recording frames to %s' % self.output_file)

          def _publish(self, bits):
              packed = np.packbits(np.asarray(bits, dtype=np.uint8), bitorder='big').tobytes()
              tm = packed[4:]
              # Check canonical frame octets after polarity normalization and ASM removal.
              expected = (sum(tm[:218]) + 0x0202) & 0xffff
              received = (tm[218] << 8) | tm[219]
              if expected != received:
                  self.rejected_frames += 1
                  print('[GGAK] checksum reject: expected=%04X received=%04X, valid=%d rejected=%d' %
                        (expected, received, self.frames, self.rejected_frames))
                  return
              meta = pmt.make_dict()
              meta = pmt.dict_add(meta, pmt.intern('checksum_valid'), pmt.PMT_T)
              meta = pmt.dict_add(meta, pmt.intern('checksum'), pmt.from_long(received))
              meta = pmt.dict_add(meta, pmt.intern('rx_time_ns'), pmt.from_long(time.time_ns()))
              meta = pmt.dict_add(meta, pmt.intern('frame_type'), pmt.intern('GGAK'))
              meta = pmt.dict_add(meta, pmt.intern('asm_errors'), pmt.from_long(self._asm_errors))
              meta = pmt.dict_add(meta, pmt.intern('cadu_length'), pmt.from_long(len(packed)))
              self.message_port_pub(pmt.intern('frames'), pmt.cons(meta, pmt.init_u8vector(len(tm), list(tm))))
              if self._fh is not None:
                  self._fh.write(tm)
                  self._fh.flush()
              self.frames += 1
              print('[GGAK] frame %d: %d bytes GGAK frame, checksum=OK, ASM errors=%d, header=%s, rejected=%d' %
                    (self.frames, len(tm), self._asm_errors, tm[:8].hex(), self.rejected_frames))

          def work(self, input_items, output_items):
              for sample in input_items[0]:
                  bit = 1 if sample.real >= 0 else 0
                  if self._collect is not None:
                      self._collect.append(bit ^ int(self._invert))
                      if len(self._collect) >= self.frame_bits:
                          bits = self._collect
                          self._collect = None
                          self._publish(bits)
                          self._locked = True
                      continue
                  self._window.append(bit)
                  if len(self._window) > 32:
                      self._window.pop(0)
                  if len(self._window) == 32:
                      w = np.asarray(self._window, dtype=np.uint8)
                      e = int(np.count_nonzero(w != ASM_BITS))
                      ei = int(np.count_nonzero((1-w) != ASM_BITS))
                      threshold = self.locked_errors if self._locked else self.search_errors
                      if min(e, ei) <= threshold:
                          self._invert = ei < e
                          self._asm_errors = min(e, ei)
                          self._collect = ASM_BITS.tolist()
                          self._window = []
              return len(input_items[0])

          def stop(self):
              if self._fh is not None:
                  self._fh.flush()
                  self._fh.close()
                  self._fh = None
              return True
    comment: 'Emits and records only 220-byte GGAK frames passing additive checksum: (sum(frame[:218])+0x0202)&0xffff, big-endian bytes 218–219.'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    comment: Optional PDU display. The embedded deframer also prints a compact one-line summary per frame.
    en_uvec: 'False'
  states: {}
- name: use_file
  id: variable
  parameters:
    comment: 'True: decode the recording (file source). False: live Pluto.'
    value: 'True'
  states: {}
- name: channel_offset_hz
  id: variable
  parameters:
    comment: Offset of GGAK in the input stream (0 for the recording; -lo_offset_hz for Pluto)
    value: 0 if use_file else -lo_offset_hz
  states: {}
- name: input_file
  id: variable
  parameters:
    comment: cs16 (interleaved int16 I/Q) recording
    value: '"GGAK_1Msps_2026-11-09_19-05-52_1000000SPS_1693000000Hz.cs16"'
  states: {}
- name: file_speed
  id: variable
  parameters:
    comment: Playback speed-up vs real time (1 = real time)
    value: '4'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: cs16 recording (interleaved int16 I,Q)
    file: input_file
    repeat: 'False'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: int16 -> +/-1.0 float
    const: 1.0/32768.0
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate*file_speed
    type: complex
  states: {}
- name: epy_block_afc
  id: epy_block
  parameters:
    samp_rate: post_rate
    nfft: '65536'
    init_blocks: '2'
    avg_blocks: '8'
    search_hz: '30000.0'
    sub_hz: symbol_rate
    min_db: '12.0'
    hyst_hz: '40.0'
    _source_code: |
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """Blind carrier acquisition + coarse AFC for residual-carrier PM / BPSK-subcarrier signals.

          Squaring a PM signal with a residual carrier produces a data-independent spectral
          line at exactly 2*f_carrier (plus weaker lines at 2*f_carrier +/- 2*subcarrier).
          The block finds that line on a long-term averaged |FFT(x^2)|^2, mixes the carrier
          to 0 Hz and hands the fine tracking to the narrow carrier PLL.

          Output is the input delayed by init_blocks*nfft samples (zeros until the first
          estimate exists), so no signal is lost while the carrier is being found.
          The mixing frequency is only changed when the new estimate differs from the
          current one by more than hyst_hz (the PLL follows slow drift by itself).
          """

          def __init__(self, samp_rate=250000.0, nfft=65536, init_blocks=2, avg_blocks=8,
                       search_hz=30000.0, sub_hz=5000.0, min_db=12.0, hyst_hz=40.0):
              gr.sync_block.__init__(self, name='PM carrier AFC',
                                     in_sig=[np.complex64], out_sig=[np.complex64])
              self.fs = float(samp_rate)
              self.nfft = int(nfft)
              self.init_blocks = int(init_blocks)
              self.avg_blocks = int(avg_blocks)
              self.search_hz = float(search_hz)
              self.sub_hz = float(sub_hz)
              self.min_db = float(min_db)
              self.hyst_hz = float(hyst_hz)
              self._win = np.hanning(self.nfft)
              self._bins = np.fft.fftfreq(self.nfft, 1.0 / self.fs)
              self._mask = np.flatnonzero(np.abs(self._bins) <= 2.0 * self.search_hz)
              self._hist = []
              self._pend = np.zeros(0, np.complex64)
              self._delay = np.zeros(self.init_blocks * self.nfft, np.complex64)
              self._f = None          # current mixing frequency [Hz]
              self._phase = 0.0
              self.last_db = 0.0
              self.estimates = 0

          def _estimate(self):
              P = np.mean(self._hist, axis=0)
              n = self.nfft
              d = int(round(2.0 * self.sub_hz * n / self.fs))
              S = P + 0.5 * (np.roll(P, d) + np.roll(P, -d))   # line at 2fc and its +/-2*sub partners
              k = self._mask[np.argmax(S[self._mask])]
              a, b, c = np.log(S[k - 1] + 1e-300), np.log(S[k] + 1e-300), np.log(S[(k + 1) % n] + 1e-300)
              den = a - 2.0 * b + c
              dl = 0.5 * (a - c) / den if den != 0 else 0.0
              f2c = self._bins[k] + dl * self.fs / n
              db = 10.0 * np.log10((P[k] + 1e-300) / (np.median(P) + 1e-300))
              return 0.5 * f2c, db

          def _analyse(self, blk):
              y = (blk.astype(np.complex128) ** 2) * self._win
              self._hist.append(np.abs(np.fft.fft(y)) ** 2)
              if len(self._hist) > self.avg_blocks:
                  self._hist.pop(0)
              if len(self._hist) < self.init_blocks:
                  return
              f, db = self._estimate()
              self.last_db = db
              if db >= self.min_db and (self._f is None or abs(f - self._f) > self.hyst_hz):
                  self._f = f
                  self.estimates += 1
                  print('[AFC] carrier %.1f Hz (line %.1f dB above floor)' % (f, db))

          def work(self, input_items, output_items):
              x = input_items[0]
              n = len(x)
              self._pend = np.concatenate([self._pend, x])
              while len(self._pend) >= self.nfft:
                  self._analyse(self._pend[:self.nfft])
                  self._pend = self._pend[self.nfft:]
              self._delay = np.concatenate([self._delay, x])
              src = self._delay[:n]
              self._delay = self._delay[n:]
              if self._f is None:
                  output_items[0][:n] = 0
                  return n
              inc = -2.0 * np.pi * self._f / self.fs
              ph = self._phase + inc * np.arange(n, dtype=np.float64)
              output_items[0][:n] = (src * np.exp(1j * ph)).astype(np.complex64)
              self._phase = float((self._phase + inc * n) % (2.0 * np.pi))
              return n
    comment: 'Blind carrier acquisition: finds the data-independent line at 2*fc in |FFT(x^2)|^2, mixes the residual carrier to 0 Hz. Output is delayed 2*65536 samples (zeros until the first estimate). Re-centres only if the carrier moves >40 Hz.'
  states: {}
- name: epy_block_norm
  id: epy_block
  parameters:
    samp_rate: timing_rate
    tau: '0.25'
    sub: '250'
    _source_code: |
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """Level-independent power normaliser (replaces analog.agc).

          GNU Radio's agc adds rate*(ref-|y|) to the gain, so with small sample amplitudes
          (e.g. int16/32768 recordings, ~1e-4) its time constant is 1/(rate*|x|) -- tens of
          seconds -- and the Costas/M&M loops see the wrong amplitude all that time.
          This block scales the stream to unit mean power with a fixed time constant,
          whatever the input level.  Silence (exact zeros) is passed through unchanged.
          """

          def __init__(self, samp_rate=50000.0, tau=0.25, sub=250):
              gr.sync_block.__init__(self, name='Power normaliser',
                                     in_sig=[np.complex64], out_sig=[np.complex64])
              self.fs = float(samp_rate)
              self.tau = float(tau)
              self.sub = int(sub)
              self.P = None

          def work(self, input_items, output_items):
              x = input_items[0]
              n = len(x)
              out = output_items[0]
              for i in range(0, n, self.sub):
                  seg = x[i:i + self.sub]
                  p = float(np.mean(seg.real.astype(np.float64) ** 2 + seg.imag.astype(np.float64) ** 2))
                  if p <= 1e-30:
                      out[i:i + len(seg)] = 0
                      continue
                  if self.P is None:
                      self.P = p
                  else:
                      a = 1.0 - np.exp(-len(seg) / (self.tau * self.fs))
                      self.P += a * (p - self.P)
                  out[i:i + len(seg)] = seg / np.sqrt(self.P)
              return n
    comment: Level-independent power normaliser (replaces analog AGC). Costas/M&M error detectors expect ~unit symbol amplitude.
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [iio_fmcomms2_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', epy_block_afc, '0']
- [epy_block_afc, '0', fir_filter_xxx_0, '0']
- [fir_filter_xxx_0, '0', analog_pll_carriertracking_cc_0, '0']
- [analog_pll_carriertracking_cc_0, '0', epy_block_pm, '0']
- [epy_block_pm, '0', fir_filter_xxx_1, '0']
- [fir_filter_xxx_1, '0', epy_block_norm, '0']
- [epy_block_norm, '0', digital_costas_loop_cc_0, '0']
- [digital_costas_loop_cc_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', qtgui_const_sink_x_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', epy_block_0, '0']
- [epy_block_0, frames, blocks_message_debug_0, print]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
