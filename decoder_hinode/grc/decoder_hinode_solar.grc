options:
  parameters:
    author: OpenAI / Dario Lucia
    category: '[Satellite]'
    description: Validated v10.2 decoder with selectable WAV or Pluto SDR input. Pluto defaults to ip:192.168.2.1, manual gain 32 dB, 2 Msps / 2 MHz, native FIR decimation to 500 kS/s.
    generate_options: qt_gui
    id: hinode_solar_v10_3_native_grsat
    output_language: python
    run_options: run
    title: Hinode S-band v10.3 — WAV or Pluto native GNU Radio + gr-satellites
  states: {}

blocks:
- name: acq_seconds
  id: variable
  parameters:
    comment: Validated v9.4.2 acquisition interval.
    value: '12.0'
  states: {}
- name: asm_errors
  id: variable
  parameters:
    comment: gr-satellites ASM error threshold.
    value: '4'
  states: {}
- name: bb_rate
  id: variable
  parameters:
    comment: Internal native DSP sample rate.
    value: file_rate
  states: {}
- name: clock_mu
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: clock_omega_limit
  id: variable
  parameters:
    value: '0.005'
  states: {}
- name: costas_block_name
  id: variable
  parameters:
    comment: Native Costas GRC block ID used by acquisition controller.
    value: '''native_costas'''
  states: {}
- name: costas_bw_acq
  id: variable
  parameters:
    value: '0.02'
  states: {}
- name: costas_bw_steady
  id: variable
  parameters:
    value: '0.005'
  states: {}
- name: file_rate
  id: variable
  parameters:
    comment: Reference SDR++ stereo-I/Q WAV sample rate.
    value: '500000'
  states: {}
- name: frame_file
  id: variable
  parameters:
    comment: 'Output: concatenated 892-byte post-RS AOS transfer frames.'
    value: '''hinode_v10_frames.tf'''
  states: {}
- name: iq_wav_file
  id: variable
  parameters:
    comment: SDR++ stereo float32 I/Q WAV.
    value: '''/absolute/path/to/Hinode_90secs.wav'''
  states: {}
- name: mm_block_name
  id: variable
  parameters:
    comment: Native M&M GRC block ID used by acquisition controller.
    value: '''native_mm'''
  states: {}
- name: mm_gain_mu_acq
  id: variable
  parameters:
    value: '0.03'
  states: {}
- name: mm_gain_mu_steady
  id: variable
  parameters:
    value: '0.01'
  states: {}
- name: mm_gain_omega_acq
  id: variable
  parameters:
    value: '0.0001'
  states: {}
- name: mm_gain_omega_steady
  id: variable
  parameters:
    value: '0.000025'
  states: {}
- name: pll_block_name
  id: variable
  parameters:
    comment: Native PLL GRC block ID used by acquisition controller.
    value: '''native_pll'''
  states: {}
- name: pll_bw_acq
  id: variable
  parameters:
    value: '0.03'
  states: {}
- name: pll_bw_steady
  id: variable
  parameters:
    value: '0.01'
  states: {}
- name: pluto_bandwidth
  id: variable
  parameters:
    comment: Pluto sample rate and RF bandwidth in Hz. Default 2 MHz / 2 Msps.
    value: '2000000'
  states: {}
- name: pluto_decimation
  id: variable
  parameters:
    comment: Automatically computed decimation factor to reach bb_rate=500 kS/s.
    value: int(pluto_bandwidth / bb_rate)
  states: {}
- name: pluto_gain
  id: variable
  parameters:
    comment: Manual Pluto RX1 gain in dB.
    value: '32'
  states: {}
- name: pluto_lpf_cutoff
  id: variable
  parameters:
    comment: Anti-alias LPF cutoff before decimation.
    value: '200000'
  states: {}
- name: pluto_lpf_taps
  id: variable
  parameters:
    comment: Native FIR taps for Pluto decimation path.
    value: firdes.low_pass(1.0, pluto_bandwidth, pluto_lpf_cutoff, pluto_lpf_transition, window.WIN_HAMMING)
  states: {}
- name: pluto_lpf_transition
  id: variable
  parameters:
    comment: Anti-alias LPF transition width before decimation.
    value: '35000'
  states: {}
- name: pluto_uri
  id: variable
  parameters:
    comment: Pluto IIO URI.
    value: '''ip:192.168.2.1'''
  states: {}
- name: rf_freq
  id: variable
  parameters:
    comment: Hinode nominal S-band telemetry frequency.
    value: '2256220000'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    comment: Exact 31-tap RRC from validated v9.4.2.
    value: '[0.003561560297,0.004399490543,0.002868671203,-0.001375013846,-0.00765449414,-0.01418049261,-0.01830869913,-0.01712624915,-0.008240184747,0.009439719841,0.03515513241,0.06617614627,0.09818095714,0.1260803193,0.1450993717,0.1518475264,0.1450993717,0.1260803193,0.09818095714,0.06617614627,0.03515513241,0.009439719841,-0.008240184747,-0.01712624915,-0.01830869913,-0.01418049261,-0.00765449414,-0.001375013846,0.002868671203,0.004399490543,0.003561560297]'
  states: {}
- name: source_select
  id: variable
  parameters:
    comment: 'Input source selector: 0 = WAV file, 1 = Pluto SDR.'
    value: '0'
  states: {}
- name: sps
  id: variable
  parameters:
    comment: Samples per symbol.
    value: bb_rate / symbol_rate
  states: {}
- name: symbol_gain
  id: variable
  parameters:
    value: '5.0'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    comment: Recovered BPSK symbol rate.
    value: '65600.0'
  states: {}
- name: acq_controller
  id: epy_block
  parameters:
    _source_code: |
      import inspect
      import threading
      import time
      from gnuradio import gr

      class blk(gr.basic_block):
          """
          Out-of-band acquisition controller.

          No stream ports: this block never processes samples. The three block-name
          parameters are ordinary GRC string variables. At runtime the controller
          resolves the corresponding native blocks from the generated top_block.
          """

          def __init__(self,
                       pll_block_name='native_pll',
                       costas_block_name='native_costas',
                       mm_block_name='native_mm',
                       sample_rate=500000.0,
                       symbol_rate=65600.0,
                       acq_seconds=12.0,
                       pll_steady=0.01,
                       costas_steady=0.005,
                       mm_mu_steady=0.01,
                       mm_omega_steady=0.000025):
              gr.basic_block.__init__(
                  self,
                  name='Hinode acquisition controller',
                  in_sig=None,
                  out_sig=None)

              self.pll_block_name = str(pll_block_name)
              self.costas_block_name = str(costas_block_name)
              self.mm_block_name = str(mm_block_name)

              self.sample_limit = int(round(float(sample_rate) * float(acq_seconds)))
              self.symbol_limit = int(round(float(symbol_rate) * float(acq_seconds)))

              self.pll_steady = float(pll_steady)
              self.costas_steady = float(costas_steady)
              self.mm_mu_steady = float(mm_mu_steady)
              self.mm_omega_steady = float(mm_omega_steady)

              # GRC instantiates the block once for introspection. In the actual
              # generated flowgraph, the caller is top_block.__init__, whose local
              # 'self' is the generated flowgraph instance.
              frame = inspect.currentframe()
              caller = frame.f_back if frame is not None else None
              parent = caller.f_locals.get('self') if caller is not None else None

              if parent is not None:
                  self._parent = parent
                  threading.Thread(
                      target=self._run,
                      daemon=True,
                      name='hinode-acquisition-control').start()

          def _resolve_blocks(self):
              # The controller can be constructed before all later blocks exist.
              # Wait briefly for the generated top_block constructor to finish.
              for _ in range(5000):
                  try:
                      pll = getattr(self._parent, self.pll_block_name)
                      costas = getattr(self._parent, self.costas_block_name)
                      mm = getattr(self._parent, self.mm_block_name)
                      return pll, costas, mm
                  except AttributeError:
                      time.sleep(0.001)
              return None, None, None

          def _run(self):
              pll, costas, mm = self._resolve_blocks()
              if pll is None or costas is None or mm is None:
                  print('[Hinode-v10.2] acquisition controller: native block lookup failed')
                  return

              carrier_done = False
              clock_done = False

              while not (carrier_done and clock_done):
                  try:
                      if (not carrier_done
                              and int(costas.nitems_written(0)) >= self.sample_limit):
                          pll.set_loop_bandwidth(self.pll_steady)
                          costas.set_loop_bandwidth(self.costas_steady)
                          carrier_done = True
                          print('[Hinode-v10.2] PLL/Costas -> steady state at ~12 s signal time')

                      if (not clock_done
                              and int(mm.nitems_written(0)) >= self.symbol_limit):
                          mm.set_gain_mu(self.mm_mu_steady)
                          mm.set_gain_omega(self.mm_omega_steady)
                          clock_done = True
                          print('[Hinode-v10.2] M&M -> steady state at ~12 s signal time')

                  except Exception as exc:
                      print('[Hinode-v10.2] acquisition controller warning:', repr(exc))
                      return

                  time.sleep(0.001)
    acq_seconds: acq_seconds
    comment: Out-of-band controller. Uses three ordinary GRC block-name variables; no stream samples pass through Python.
    costas_block_name: costas_block_name
    costas_steady: costas_bw_steady
    mm_block_name: mm_block_name
    mm_mu_steady: mm_gain_mu_steady
    mm_omega_steady: mm_gain_omega_steady
    pll_block_name: pll_block_name
    pll_steady: pll_bw_steady
    sample_rate: bb_rate
    symbol_rate: symbol_rate
  states: {}
- name: constellation
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    comment: Recovered 1-sample/symbol constellation. GUI only; disable for maximum benchmark speed.
    grid: 'True'
    gui_hint: 0,1,1,1
    label1: native M&M output
    legend: 'False'
    name: Hinode recovered BPSK symbols
    size: '4096'
    type: complex
    update_time: '0.25'
  states: {}
- name: deframe_p0_inverted
  id: satellites_ccsds_concatenated_deframer
  parameters:
    comment: Pair phase 0 / inverted polarity.
    convolutional: '"CCSDS"'
    frame_size: 223 * 4
    precoding: None
    rs_basis: '"dual"'
    rs_interleaving: '4'
    scrambler: '"CCSDS"'
    threshold: asm_errors
  states: {}
- name: deframe_p0_normal
  id: satellites_ccsds_concatenated_deframer
  parameters:
    comment: Pair phase 0 / normal polarity.
    convolutional: '"CCSDS"'
    frame_size: 223 * 4
    precoding: None
    rs_basis: '"dual"'
    rs_interleaving: '4'
    scrambler: '"CCSDS"'
    threshold: asm_errors
  states: {}
- name: deframe_p1_inverted
  id: satellites_ccsds_concatenated_deframer
  parameters:
    comment: Pair phase 1 / inverted polarity.
    convolutional: '"CCSDS"'
    frame_size: 223 * 4
    precoding: None
    rs_basis: '"dual"'
    rs_interleaving: '4'
    scrambler: '"CCSDS"'
    threshold: asm_errors
  states: {}
- name: deframe_p1_normal
  id: satellites_ccsds_concatenated_deframer
  parameters:
    comment: Pair phase 1 / normal polarity.
    convolutional: '"CCSDS"'
    frame_size: 223 * 4
    precoding: None
    rs_basis: '"dual"'
    rs_interleaving: '4'
    scrambler: '"CCSDS"'
    threshold: asm_errors
  states: {}
- name: frame_collector
  id: epy_block
  parameters:
    _source_code: |
      from collections import deque
      from pathlib import Path
      import pmt
      from gnuradio import gr

      class blk(gr.basic_block):
          """
          Low-rate four-branch gr-satellites PDU collector.

          It does not process streaming samples. Exact duplicate frames emitted by
          parallel ambiguity branches are suppressed using the last three accepted
          payloads, matching the proven SatDecode receiver strategy.
          """
          def __init__(self, outfile='hinode_v10_frames.tf'):
              gr.basic_block.__init__(
                  self, name='Hinode four-branch PDU collector',
                  in_sig=None, out_sig=None)

              self.outfile = str(outfile)
              self.recent = deque(maxlen=3)
              self.count = 0
              self.duplicates = 0
              self.branch_counts = {
                  'p0_normal': 0,
                  'p0_inverted': 0,
                  'p1_normal': 0,
                  'p1_inverted': 0,
              }

              p = Path(self.outfile).expanduser()
              if p.parent != Path('.'):
                  p.parent.mkdir(parents=True, exist_ok=True)
              self.f = p.open('wb')

              for name in self.branch_counts:
                  port = pmt.intern(name)
                  self.message_port_register_in(port)

              self.set_msg_handler(pmt.intern('p0_normal'), self._p0_normal)
              self.set_msg_handler(pmt.intern('p0_inverted'), self._p0_inverted)
              self.set_msg_handler(pmt.intern('p1_normal'), self._p1_normal)
              self.set_msg_handler(pmt.intern('p1_inverted'), self._p1_inverted)

          @staticmethod
          def _payload(msg):
              obj = pmt.cdr(msg) if pmt.is_pair(msg) else msg
              return bytes(pmt.u8vector_elements(obj))

          def _p0_normal(self, msg): self._handle('p0_normal', msg)
          def _p0_inverted(self, msg): self._handle('p0_inverted', msg)
          def _p1_normal(self, msg): self._handle('p1_normal', msg)
          def _p1_inverted(self, msg): self._handle('p1_inverted', msg)

          def _handle(self, branch, msg):
              data = self._payload(msg)
              self.branch_counts[branch] += 1

              if data in self.recent:
                  self.duplicates += 1
                  return

              self.recent.append(data)
              self.f.write(data)
              self.count += 1

              if self.count <= 5 or (self.count % 25) == 0:
                  vcid = (data[1] & 0x3f) if len(data) >= 2 else -1
                  print('[Hinode-v10] frame=%d branch=%s bytes=%d VCID=%d' %
                        (self.count, branch, len(data), vcid))

          def stop(self):
              try:
                  self.f.flush()
                  self.f.close()
              except Exception:
                  pass
              print('[Hinode-v10] accepted frames=%d duplicates=%d branches=%s' %
                    (self.count, self.duplicates,
                     ' '.join('%s=%d' % (k,v) for k,v in self.branch_counts.items())))
              print('[Hinode-v10] output=%s (892-byte post-RS transfer frames)' % self.outfile)
              return True
    comment: Low-rate PDU-only collector/deduplicator. No streaming DSP in Python.
    outfile: frame_file
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from gnuradio.fft import window
  states: {}
- name: import_firdes
  id: import
  parameters:
    comment: Explicit import for Pluto decimating FIR tap design.
    imports: from gnuradio.filter import firdes
  states: {}
- name: import_math
  id: import
  parameters:
    imports: import math
  states: {}
- name: invert_p0
  id: blocks_multiply_const_vxx
  parameters:
    comment: BPSK polarity-inverted branch.
    const: '-1.0'
    type: float
  states: {}
- name: invert_p1
  id: blocks_multiply_const_vxx
  parameters:
    comment: Inverted polarity for pair-phase-1 branch.
    const: '-1.0'
    type: float
  states: {}
- name: iq_wav_source
  id: blocks_wavfile_source
  parameters:
    comment: Offline SDR++ stereo IQ WAV source. Channel 0 = I, channel 1 = Q. Repeat is disabled so the flowgraph ends at EOF.
    file: /mnt/temp/Mullberg28092026/Hinode_90secs.wav
    nchan: '2'
    repeat: 'False'
  states: {}
- name: native_agc
  id: analog_agc_xx
  parameters:
    comment: Native replacement for validated SatDump-equivalent AGC.
    gain: '1.0'
    max_gain: '65536.0'
    rate: '0.001'
    reference: '1.0'
    type: complex
  states: {}
- name: native_costas
  id: digital_costas_loop_cc
  parameters:
    comment: Native BPSK Costas loop. Acquisition -> steady switch at 12 s.
    order: '2'
    w: costas_bw_acq
  states: {}
- name: native_dc_iir
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '0.0001'
    comment: Native GNU Radio Single Pole IIR Filter; complex, alpha=0.0001.
    type: complex
  states: {}
- name: native_dc_sub
  id: blocks_sub_xx
  parameters:
    comment: 'CorrectIQ equivalent: y=x-running_DC_estimate.'
    type: complex
  states: {}
- name: native_mm
  id: digital_clock_recovery_mm_xx
  parameters:
    comment: Native Mueller & Muller timing recovery; same initial omega/mu/limits as v9.4.2.
    gain_mu: mm_gain_mu_acq
    gain_omega: mm_gain_omega_acq
    mu: clock_mu
    omega: sps
    omega_relative_limit: clock_omega_limit
    type: complex
  states: {}
- name: native_pll
  id: analog_pll_carriertracking_cc
  parameters:
    comment: Residual-carrier PLL. Starts at acquisition bandwidth; controller changes to steady bandwidth.
    max_freq: '0.5'
    min_freq: '-0.5'
    w: pll_bw_acq
  states: {}
- name: native_rrc
  id: fir_filter_xxx
  parameters:
    comment: Exact 31-tap validated RRC, implemented by native FIR.
    decim: '1'
    taps: rrc_taps
    type: ccf
  states: {}
- name: native_symbol_gain
  id: blocks_multiply_const_vxx
  parameters:
    comment: Fixed symbol gain used by the validated receiver.
    const: symbol_gain
    type: complex
  states: {}
- name: pluto_decim
  id: fir_filter_xxx
  parameters:
    comment: Native complex FIR decimator. Factor is pluto_bandwidth/bb_rate (4 at 2 Msps).
    decim: pluto_decimation
    taps: pluto_lpf_taps
    type: ccf
  states: {}
- name: pluto_source
  id: iio_fmcomms2_source
  parameters:
    bandwidth: pluto_bandwidth
    bbdc: 'True'
    buffer_size: '65536'
    comment: Pluto Plus live source. 2 Msps / 2 MHz by default, manual gain 32 dB.
    filter: ''''''
    filter_source: '''Auto'''
    frequency: rf_freq
    gain1: '''manual'''
    len_tag_key: '""'
    manual_gain1: pluto_gain
    quadrature: 'True'
    rf_port_select: '''A_BALANCED'''
    rfdc: 'True'
    rx1_en: 'True'
    rx2_en: 'False'
    samplerate: pluto_bandwidth
    type: fc32
    uri: pluto_uri
  states: {}
- name: q_extract
  id: blocks_complex_to_float
  parameters:
    comment: Use Q/imaginary component exactly as validated PM-to-BPSK extraction.
  states: {}
- name: q_real_null_sink
  id: blocks_null_sink
  parameters:
    comment: Discard q_extract real output; imaginary/Q continues to demodulation.
    type: float
  states: {}
- name: q_to_complex
  id: blocks_float_to_complex
  parameters:
    comment: Reconstruct 0+jQ.
  states: {}
- name: skip_one
  id: blocks_skiphead
  parameters:
    comment: 'Second convolutional coded-pair phase: skip one soft symbol.'
    num_items: '1'
    type: float
  states: {}
- name: soft_real
  id: blocks_complex_to_real
  parameters:
    comment: Float soft symbols for gr-satellites.
  states: {}
- name: source_selector
  id: blocks_selector
  parameters:
    comment: Select 0=WAV path or 1=Pluto path. Both selector inputs are normalized to 500 kS/s.
    enabled: 'True'
    input_index: source_select
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: spectrum
  id: qtgui_freq_sink_x
  parameters:
    bw: bb_rate
    comment: Raw 500 ksps input spectrum, matching SatDump no-resample configuration.
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    gui_hint: 0,0,1,1
    label1: Hinode baseband
    name: Hinode input spectrum
    type: complex
    update_time: '0.25'
    ymin: '-100'
  states: {}
- name: subcarrier_rotator
  id: blocks_rotator_cc
  parameters:
    comment: Continuous -65.6 kHz complex rotation.
    phase_inc: '-2.0 * math.pi * symbol_rate / bb_rate'
  states: {}
- name: wav_iq_to_complex
  id: blocks_float_to_complex
  parameters:
    comment: 'Reconstruct complex baseband: channel 0 -> I, channel 1 -> Q.'
  states: {}
- name: zero_float
  id: analog_const_source_x
  parameters:
    comment: Zero real component for reconstructed j*Q signal.
    const: '0.0'
    type: float
  states: {}

connections:
- [deframe_p0_inverted, out, frame_collector, p0_inverted]
- [deframe_p0_normal, out, frame_collector, p0_normal]
- [deframe_p1_inverted, out, frame_collector, p1_inverted]
- [deframe_p1_normal, out, frame_collector, p1_normal]
- [invert_p0, '0', deframe_p0_inverted, '0']
- [invert_p1, '0', deframe_p1_inverted, '0']
- [iq_wav_source, '0', wav_iq_to_complex, '0']
- [iq_wav_source, '1', wav_iq_to_complex, '1']
- [native_agc, '0', native_pll, '0']
- [native_costas, '0', native_mm, '0']
- [native_dc_iir, '0', native_dc_sub, '1']
- [native_dc_sub, '0', native_agc, '0']
- [native_mm, '0', native_symbol_gain, '0']
- [native_pll, '0', q_extract, '0']
- [native_rrc, '0', native_costas, '0']
- [native_symbol_gain, '0', constellation, '0']
- [native_symbol_gain, '0', soft_real, '0']
- [pluto_decim, '0', source_selector, '1']
- [pluto_source, '0', pluto_decim, '0']
- [q_extract, '0', q_real_null_sink, '0']
- [q_extract, '1', q_to_complex, '1']
- [q_to_complex, '0', subcarrier_rotator, '0']
- [skip_one, '0', deframe_p1_normal, '0']
- [skip_one, '0', invert_p1, '0']
- [soft_real, '0', deframe_p0_normal, '0']
- [soft_real, '0', invert_p0, '0']
- [soft_real, '0', skip_one, '0']
- [source_selector, '0', native_dc_iir, '0']
- [source_selector, '0', native_dc_sub, '0']
- [source_selector, '0', spectrum, '0']
- [subcarrier_rotator, '0', native_rrc, '0']
- [wav_iq_to_complex, '0', source_selector, '0']
- [zero_float, '0', q_to_complex, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
